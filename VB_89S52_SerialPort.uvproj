# Keil uVision project VB_89S52_SerialPort.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: VB_89S52_SerialPort +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: main.c
    ./User/uart/: uart.c
    ./User/lcd1602/: lcd1602.c
    ./User/delay/: delay.c
